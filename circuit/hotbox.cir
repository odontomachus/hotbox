* EESchema Netlist Version 1.1 (Spice format) creation date: Tue 09 Jun 2015 06:11:32 PM EDT

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
IC1  Net-_IC1-Pad1_ ? GND +3V3 GND +3V3 Net-_C5-Pad2_ Net-_C6-Pad2_ ? ? /zc ? ? ? Net-_IC1-Pad15_ Net-_IC1-Pad16_ Net-_IC1-Pad17_ +3V3 ? Net-_C4-Pad2_ GND ? ? ? ? ? /TH1 /TH2 Net-_IC1-Pad29_ Net-_IC1-Pad30_ Net-_IC1-Pad31_ Net-_IC1-Pad32_ ATMEGA48A-M
TH1  GND ? THERMISTOR
TH2  GND ? THERMISTOR
R2  /TH1 +3V3 R
R3  /TH2 +3V3 R
X1  Net-_C5-Pad2_ Net-_C6-Pad2_ CRYSTAL
C5  GND Net-_C5-Pad2_ 12pF
C6  GND Net-_C6-Pad2_ 12pF
R7  Net-_D3-Pad3_ Net-_R7-Pad2_ 22kR
R8  Net-_D3-Pad1_ Net-_R8-Pad2_ 22kR
R1  /zc +3V3 4.7kR
K1  /live /load /neutral CONN_3
D1  Net-_D1-Pad1_ GND LED-orange
D2  Net-_D2-Pad1_ GND LED-green
R4  Net-_R4-Pad1_ Net-_IC1-Pad16_ R
P1  Net-_P1-Pad1_ GND CONN_2
C2  +3V3 GND 220uF
C4  GND Net-_C4-Pad2_ 0.1uF
P2  GND /TH1 ? ? /TH2 CONN_5
U3  /load /live Net-_U2-Pad4_ BTA312Y-600C
U1  GND +3V3 Net-_P1-Pad1_ NCP1117ST33T3G
R10  Net-_R10-Pad1_ /live 330R
D3  Net-_D3-Pad1_ /live Net-_D3-Pad3_ /neutral BRIDGE
P3  Net-_IC1-Pad31_ Net-_IC1-Pad30_ GND +3V3 CONN_4
P4  Net-_IC1-Pad16_ Net-_IC1-Pad17_ Net-_IC1-Pad29_ GND Net-_IC1-Pad15_ +3V3 CONN_3X2
U2  Net-_R4-Pad1_ GND Net-_U2-Pad4_ Net-_R10-Pad1_ OPTO-TRIAC
C3  GND +3V3 220uF
C1  GND +3V3 C
D4  Net-_D4-Pad1_ GND LED-blue
U4  Net-_R7-Pad2_ Net-_R8-Pad2_ GND /zc OPTO-TRANSISTOR4
RP1  +3V3 Net-_IC1-Pad1_ ? Net-_IC1-Pad32_ Net-_D1-Pad1_ ? Net-_D2-Pad1_ Net-_D4-Pad1_ 82R
*Sheet Name:/thermistor/

.end
